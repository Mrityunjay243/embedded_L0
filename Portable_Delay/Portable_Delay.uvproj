# Keil uVision project Portable_Delay.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8052 (all Variants) Generic
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(12000000)
  output: Portable_Delay
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Delay_t0.c main.c LED_flash.c
