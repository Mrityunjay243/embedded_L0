# Keil uVision project 2_01_12g.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S53 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x2FFF) CLOCK(24000000) MODA2
  output: 2_01_12g +hex
  c flags: Optimize=6 SizeSpeed=1
  group Source Group 1
    ./: 2_01_12G.C LED_FLAS.C MAIN.C SCH51.C
