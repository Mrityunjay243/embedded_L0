# Keil uVision project Hybrid_Scheduler.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 2_01_12h +hex
  c flags: Optimize=6 SizeSpeed=1
  link misc: OVERLAY (main ~ (LED_Short_Update, LED_Long_Update),hSCH_dispatch_tasks ! (LED_Short_Update, LED_Long_Update))
  group Source Group 1
    ./: MAIN.C DELAY_T0.C HSCH51.C LED_HYB.C 2_01_12H.C
