# Keil uVision project Time.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8052 (all Variants) Generic
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(12000000)
  output: Time
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Main.c CHAR_MAP.c PC_O.c PC_O_T1.c Simple_EOS.c
